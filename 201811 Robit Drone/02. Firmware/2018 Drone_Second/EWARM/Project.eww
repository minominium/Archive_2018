<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2018 Drone_Second.ewp</path>
  </project>
  <batchBuild />
</workspace>
